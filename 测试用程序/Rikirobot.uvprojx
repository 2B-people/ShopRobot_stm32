# Keil uVision project Rikirobot.uvprojx, settings and files
target rikirobot (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: robot +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Bsp;.\Driver;.\Stm32Libs\STM32F10x_StdPeriph_Driver\inc;.\Stm32Libs\STM32F10x_StdPeriph_Driver;.\Stm32Libs\CMSIS_CM3;.\RosLibs;.\Stm32Libs\CMSIS\CM3\CoreSupport
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.cpp
  group Library
    ./Stm32Libs/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Driver
    ./Driver/: led.cpp motor.cpp PID.cpp Kinematics.cpp oled.c control.cpp las_measure.cpp
  group Bsp
    ./Bsp/: millisecondtimer.c Wire.cpp WireBase.cpp interrupt.cpp RingBuffer.cpp hardwareserial.cpp timer.cpp remote.cpp
  group Startup
    ./Stm32Libs/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ./Stm32Libs/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Stm32Libs/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group RosLib
    ./RosLibs/: duration.cpp time.cpp
